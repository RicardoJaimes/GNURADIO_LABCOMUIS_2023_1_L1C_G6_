options:
  parameters:
    author: RicardoJaimes_AndresBarreto_L1C_G06
    generate_options: qt_gui
    id: ConfiguracionUSRP
    output_language: python
    title: modulador de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la portadora
    start: '0'
    step: '1e-3'
    stop: '4'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: amplitud del mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: cambio de bandas
    start: '1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuenciaPortadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: 1e3
  states: {}
- name: k
  id: variable_qtgui_range
  parameters:
    label: habilita portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/8
  states: {}
- name: CalculoDePotenciaComunicaciones_0
  id: CalculoDePotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: Modulador_AM_L1C_G06_0
  id: Modulador_AM_L1C_G06
  parameters:
    Ac: '1'
    ka: '0.5'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: ec_SSB_0
  id: ec_SSB
  parameters:
    Ac: '1'
    B: '1'
    K: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: y
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Modulador_AM_L1C_G06_0, '0', qtgui_freq_sink_x_0, '0']
- [Modulador_AM_L1C_G06_0, '0', qtgui_time_sink_x_1, '0']
- [analog_sig_source_x_0, '0', CalculoDePotenciaComunicaciones_0, '0']
- [analog_sig_source_x_0, '0', Modulador_AM_L1C_G06_0, '0']
- [analog_sig_source_x_0, '0', ec_SSB_0, '0']
- [ec_SSB_0, '0', uhd_usrp_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
